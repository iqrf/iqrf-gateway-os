# enable openssl
EXTRA_OECMAKE = "-DPAHO_WITH_SSL=ON"
