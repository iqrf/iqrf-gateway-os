require iqrf-gatewayos-image-base.inc

IMAGE_INSTALL += ""
